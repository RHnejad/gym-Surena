Commit message: Update sfixed.urdf

File: gym_Surena/envs/SURENA/sfixed.urdf (robot description, URDF)
Before this commit: robot rrbot, 29 links, 28 joints
Joints:
- joint LArm_ElbowP_J4: limit lower=-1000.0 upper=-1000.0 effort=300.0 velocity=0.5 -> (none)
